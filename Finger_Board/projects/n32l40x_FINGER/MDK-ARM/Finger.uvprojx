# Keil uVision project Finger.uvprojx, settings and files
target N32L40x (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: N32L406MB Nationstech
  pack: Nationstech.N32L40x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: InputCapture +hex
  AfterMake: fromelf --bin --output=.\bin\InputCapture.bin .\Objects\InputCapture.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER
  c include: ..\inc\Algorithm;..\inc\Apps;..\inc\Device;..\inc\Peripheral;..\inc\Tools;..\..\..\firmware\CMSIS\core;..\..\..\firmware\CMSIS\device;..\..\..\firmware\n32l40x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../../firmware/CMSIS/device/: system_n32l40x.c
  group USER
    ../src/Apps/: main.c n32l40x_it.c
  group FWLB
    ../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_comp.c n32l40x_can.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_usart.c n32l40x_wwdg.c
  group Algorithm
    ../src/Algorithm/: filters.c PID.c
  group Apps
    ../src/Apps/: recvCmdTask.c mainTask.c
  group Device
    ../src/Device/: WS2812.c VOFA.c N20.c
  group BSP
    ../src/Peripheral/: OPAMP.c USART.c TIM9_PWM.c TIM6_CNT.c TIM2_ENC.c TIM1_PWM.c LED.c TIM4_ENC.c
  group Tools
    ../src/Tools/: user_lib.c SignalGenerator.c RingBuffer.c clock.c
